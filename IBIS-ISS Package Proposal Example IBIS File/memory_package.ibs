[IBIS Ver]   7.0
[File Name]   memory_package.ibs
[Date]   02/11/2014
[File Rev]   1.2
[Source]   Randy Wolf and Walter Katz
[Notes]   Revision History:
   Rev 1.0: 02/11/2014
[Disclaimer]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
[Component]   memory_package
[Package]
|   typ   min   max
R_pkg   200.0m   200.0m   200.0m
L_pkg   1.0nH   1.0nH   1.0nH
C_pkg   0.5pF   0.5pF   0.5pF
[Pin]   signal_name   model_name   R_pin   L_pin   C_pin
A1   VDD   POWER
A2   VSSQ   GND
A3   NF   NF_INPUT   200.0m   1.0nH 00 0.5pF
A7   NF   NF_INPUT   200.0m   1.0nH 00 0.5pF
A8   VSSQ   GND
A9   VSS   GND
B1   VPP   POWER
B2   VDDQ   POWER
B3   DQS_c   DQS   200.0m   1.0nH 00 0.5pF
B7   DQ1   DQ   200.0m   1.0nH 00 0.5pF
B8   VDDQ   POWER
B9   ZQ   NC
C1   VDDQ   POWER
C2   DQ0   DQ   200.0m   1.0nH 00 0.5pF
C3   DQS_t   DQS   200.0m   1.0nH 00 0.5pF
C7   VDD   POWER
C8   VSS   GND
C9   VDDQ   POWER
D1   VSSQ   GND
D2   NC   NC
D3   DQ2   DQ   200.0m   1.0nH 00 0.5pF
D7   DQ3   DQ   200.0m   1.0nH 00 0.5pF
D8   NC   NC
D9   VSSQ   GND
E1   VSSL   GND
E2   VDDQ   POWER
E3   NC   NC
E7   NC   NC
E8   VDDQ   POWER
E9   VSS   GND
F1   VDDL   POWER
F2   NC   NC
F3   ODT   INPUT   200.0m   1.0nH 00 0.5pF
F7   CK_t   CLKIN   200.0m   1.0nH 00 0.5pF
F8   CK_c   CLKIN   200.0m   1.0nH 00 0.5pF
F9   VDD   POWER
G1   VSS   GND
G2   NC   NC
G3   CKE   INPUT   200.0m   1.0nH 00 0.5pF
G7   CS_n   INPUT   200.0m   1.0nH 00 0.5pF
G8   NC   NC
G9   RFU   NC
H1   VDD   POWER
H2   WE_n_A14   INPUT   200.0m   1.0nH 00 0.5pF
H3   ACT_n   INPUT   200.0m   1.0nH 00 0.5pF
H7   CAS_n_A15   INPUT   200.0m   1.0nH 00 0.5pF
H8   RAS_n   INPUT   200.0m   1.0nH 00 0.5pF
H9   VSS   GND
J1   VREFCA   POWER
J2   BG0   INPUT   200.0m   1.0nH 00 0.5pF
J3   A10   INPUT   200.0m   1.0nH 00 0.5pF
J7   A12_BC_n   INPUT   200.0m   1.0nH 00 0.5pF
J8   BG1   INPUT   200.0m   1.0nH 00 0.5pF
J9   VDD   POWER
K1   VSS   GND
K2   BA0   INPUT   200.0m   1.0nH 00 0.5pF
K3   A4   INPUT   200.0m   1.0nH 00 0.5pF
K7   A3   INPUT   200.0m   1.0nH 00 0.5pF
K8   BA1   INPUT   200.0m   1.0nH 00 0.5pF
K9   VSS   GND
L1   RESET_n   RESET   200.0m   1.0nH 00 0.5pF
L2   A6   INPUT   200.0m   1.0nH 00 0.5pF
L3   A0   INPUT   200.0m   1.0nH 00 0.5pF
L7   A1   INPUT   200.0m   1.0nH 00 0.5pF
L8   A5   INPUT   200.0m   1.0nH 00 0.5pF
L9   ALERT_n   ALERT   200.0m   1.0nH 00 0.5pF
M1   VDD   POWER
M2   A8   INPUT   200.0m   1.0nH 00 0.5pF
M3   A2   INPUT   200.0m   1.0nH 00 0.5pF
M7   A9   INPUT   200.0m   1.0nH 00 0.5pF
M8   A7   INPUT   200.0m   1.0nH 00 0.5pF
M9   VPP   POWER
N1   VSS   GND
N2   A11   INPUT   200.0m   1.0nH 00 0.5pF
N3   PARITY   INPUT   200.0m   1.0nH 00 0.5pF
N7   NC   NC
N8   A13   INPUT   200.0m   1.0nH 00 0.5pF
N9   VDD   POWER
|***********************PIN MAPPING*****************************************
[Buffer Supply Terminals]   pulldown_ref   pullup_ref   gnd_clamp_ref   power_clamp_ref ext_ref
A3   NC   NC   VSSQ   VDDQ
A7   NC   NC   VSSQ   VDDQ
B3   VSSQ   VDDQ   VSSQ   VDDQ
B7   VSSQ   VDDQ   VSSQ   VDDQ
C2   VSSQ   VDDQ   VSSQ   VDDQ
C3   VSSQ   VDDQ   VSSQ   VDDQ
D3   VSSQ   VDDQ   VSSQ   VDDQ
D7   VSSQ   VDDQ   VSSQ   VDDQ
F3   NC   NC   VSS   VDD
F7   NC   NC   VSS   VDD
F8   NC   NC   VSS   VDD
G3   NC   NC   VSS   VDD
G7   NC   NC   VSS   VDD
H2   NC   NC   VSS   VDD
H3   NC   NC   VSS   VDD
H7   NC   NC   VSS   VDD
H8   NC   NC   VSS   VDD
J2   NC   NC   VSS   VDD
J3   NC   NC   VSS   VDD
J7   NC   NC   VSS   VDD
J8   NC   NC   VSS   VDD
K2   NC   NC   VSS   VDD
K3   NC   NC   VSS   VDD
K7   NC   NC   VSS   VDD
K8   NC   NC   VSS   VDD
L1   NC   NC   VSS   VDD
L2   NC   NC   VSS   VDD
L3   NC   NC   VSS   VDD
L7   NC   NC   VSS   VDD
L8   NC   NC   VSS   VDD
L9   VSS   VDDQ   VSS   VDDQ
M2   NC   NC   VSS   VDD
M3   NC   NC   VSS   VDD
M7   NC   NC   VSS   VDD
M8   NC   NC   VSS   VDD
N2   NC   NC   VSS   VDD
N3   NC   NC   VSS   VDD
N8   NC   NC   VSS   VDD
|**********************DIFF PIN*********************************************
[Diff_pin]   inv_pin   vdiff   tdelay_typ   tdelay_min   tdelay_max
   C3   B3   0.000V   0ns   NA   NA
   F7   F8   0.250V   0ns   NA   NA
[Begin Package Models]
[Begin Package Model] IO
| This model uses all I/O pins. There are ports for each I/O pin and it's buffer
Language Touchstone
File Value io.s56p
Ports  Pin.A3  Pin.A7  Pin.B3  Pin.B7  Pin.C2  Pin.C3  Pin.D3  Pin.D7  Pin.F3  Pin.N8
Ports  Pin.F7  Pin.F8  Pin.G3  Pin.G7  Pin.H2  Pin.H3  Pin.H7  Pin.H8  Pin.J2  Pin.J3
Ports  Pin.J7  Pin.J8  Pin.K2  Pin.K3  Pin.K7  Pin.K8  Pin.L1  Pin.L2  Pin.L3  Pin.L7
Ports  Pin.L8  Pin.L9  Pin.M2  Pin.M3  Pin.M7  Pin.M8  Pin.N2  Pin.N3
Ports  Buf.A3  Buf.A7  Buf.B3  Buf.B7  Buf.C2  Buf.C3  Buf.D3  Buf.D7  Buf.F3  Buf.N8
Ports  Buf.F7  Buf.F8  Buf.G3  Buf.G7  Buf.H2  Buf.H3  Buf.H7  Buf.H8  Buf.J2  Buf.J3
Ports  Buf.J7  Buf.J8  Buf.K2  Buf.K3  Buf.K7  Buf.K8  Buf.L1  Buf.L2  Buf.L3  Buf.L7
Ports  Buf.L8  Buf.L9  Buf.M2  Buf.M3  Buf.M7  Buf.M8  Buf.N2  Buf.N3
[End Package Model]
[Begin Package Model] Power_One_Die_Node_Per_Rail
| This model uses package subckt One_Per_Rail, with 10pf on-die capacitiance for this silicon
| Ports are all of the Power and GND pins, and one port for each on-die voltage
Language IBIS-ISS
File Value One_Per_Rail.iss
Subckt Value One_Per_Rail
Parameter Value Cdie_VDD Value 10pf
Parameter Value Cdie_VDDQ Value 4f
Ports Pin.A1 Pin.A2 Pin.A8 Pin.A9 Pin.B2 Pin.B8 Pin.C1 Pin.C7 Pin.C8 Pin.C9 Pin.D1 Pin.E2
Ports Pin.E8 Pin.E9 Pin.F9 Pin.G1 Pin.H1 Pin.H9 Pin.J9 Pin.K1 Pin.K9 Pin.M1 Pin.N1 Pin.N9
Ports Buf_Sig.VSSQ Buf_Sig.VSS Buf_Sig.VDD Buf_Sig.VDDQ
[End Package Model]
[End Package Models]
| Ports are all of the Power and GND pins,  PUR and PDR (or PCR and GCR) ports for each buffer
[Begin Package Model] Power_One_Die_Node_Per_Buffer
Language IBIS-ISS
File Value One_Per_Buffer.iss
Subckt Value One_Per_Buffer
Ports Pin.A1 Pin.A2 Pin.A8 Pin.A9 Pin.B2 Pin.B8 Pin.C1 Pin.C7 Pin.C8 Pin.C9 Pin.D1 Pin.E2
Ports Pin.E8 Pin.E9 Pin.F9 Pin.G1 Pin.H1 Pin.H9 Pin.J9 Pin.K1 Pin.K9 Pin.M1 Pin.N1 Pin.N9
Ports Buf_GCR.A3 Buf_PCR.A3 Buf_GCR.A7 Buf_PCR.A7 Buf_PDR.B3 Buf_PUR.B3 Buf_PDR.B7 Buf_PUR.B7
Ports Buf_PDR.C2 Buf_PUR.C2 Buf_PDR.C3 Buf_PUR.C3 Buf_PDR.D3 Buf_PUR.D3 Buf_PDR.D7 Buf_PUR.D7
Ports Buf_GCR.F3 Buf_PCR.F3 Buf_GCR.F7 Buf_PCR.F7 Buf_GCR.F8 Buf_PCR.F8 Buf_GCR.G3 Buf_PCR.G3
Ports Buf_GCR.G7 Buf_PCR.G7 Buf_GCR.H2 Buf_PCR.H2 Buf_GCR.H3 Buf_PCR.H3 Buf_GCR.H7 Buf_PCR.H7
Ports Buf_GCR.H8 Buf_PCR.H8 Buf_GCR.J2 Buf_PCR.J2 Buf_GCR.J3 Buf_PCR.J3 Buf_GCR.J7 Buf_PCR.J7
Ports Buf_GCR.J8 Buf_PCR.J8 Buf_GCR.K2 Buf_PCR.K2 Buf_GCR.K3 Buf_PCR.K3 Buf_GCR.K7 Buf_PCR.K7
Ports Buf_GCR.K8 Buf_PCR.K8 Buf_GCR.L1 Buf_PCR.L1 Buf_GCR.L2 Buf_PCR.L2 Buf_GCR.L3 Buf_PCR.L3
Ports Buf_GCR.L7 Buf_PCR.L7 Buf_GCR.L8 Buf_PCR.L8 Buf_PDR.L9 Buf_PUR.L9 Buf_GCR.M2 Buf_PCR.M2
Ports Buf_GCR.M3 Buf_PCR.M3 Buf_GCR.M7 Buf_PCR.M7 Buf_GCR.M8 Buf_PCR.M8 Buf_GCR.N2 Buf_PCR.N2
Ports Buf_GCR.N3 Buf_PCR.N3 Buf_GCR.N8 Buf_PCR.N8
[End Package Model]
| Seperate PDN for Package and Die, requires declaration of PDN Die Supply Pads
[Die Supply Pads]
VDD1 VDD
VDD2 VDD
VDD3 VDD
VSS1 VSS
VSS2 VSS
VSS3 VSS
VSSQ VSSQ
VDDQ VDDQ
VSSQ VSSQ
[End Die Supply Pads]
[Begin Package Model] Package_One_Die_Node_Per_Buffer
| Ports are all of the Power and GND die pads,  PUR and PDR (or PCR and GCR) ports for each buffer
Language IBIS-ISS
File Value Package_One_Per_Buffer.iss
Subckt Value Package_One_Per_Buffer
Ports Pad.VDD1 Pad.VDD2 Pad.VDD3 Pad.VSS1 Pad.VSS2 Pad.VSS3 Pad.VSSQ Pad.VDDQ Pad.VSSQ
Ports Pin.A1 Pin.A2 Pin.A8 Pin.A9 Pin.B2 Pin.B8 Pin.C1 Pin.C7 Pin.C8 Pin.C9 Pin.D1 Pin.E2
Ports Pin.E8 Pin.E9 Pin.F9 Pin.G1 Pin.H1 Pin.H9 Pin.J9 Pin.K1 Pin.K9 Pin.M1 Pin.N1 Pin.N9
[End Package Model]
[Begin Package Model] Die_One_Die_Node_Per_Buffer
| Ports are all of the Power and GND die pads,  PUR and PDR port for each buffer
Language IBIS-ISS
File Value Die_One_Per_Buffer.iss
Subckt Value Die_One_Per_Buffer
Ports Pad.VDD1 Pad.VDD2 Pad.VDD3 Pad.VSS1 Pad.VSS2 Pad.VSS3 Pad.VSSQ Pad.VDDQ Pad.VSSQ
Ports Buf_GCR.A3 Buf_PCR.A3 Buf_GCR.A7 Buf_PCR.A7 Buf_PDR.B3 Buf_PUR.B3 Buf_PDR.B7 Buf_PUR.B7
Ports Buf_PDR.C2 Buf_PUR.C2 Buf_PDR.C3 Buf_PUR.C3 Buf_PDR.D3 Buf_PUR.D3 Buf_PDR.D7 Buf_PUR.D7
Ports Buf_GCR.F3 Buf_PCR.F3 Buf_GCR.F7 Buf_PCR.F7 Buf_GCR.F8 Buf_PCR.F8 Buf_GCR.G3 Buf_PCR.G3
Ports Buf_GCR.G7 Buf_PCR.G7 Buf_GCR.H2 Buf_PCR.H2 Buf_GCR.H3 Buf_PCR.H3 Buf_GCR.H7 Buf_PCR.H7
Ports Buf_GCR.H8 Buf_PCR.H8 Buf_GCR.J2 Buf_PCR.J2 Buf_GCR.J3 Buf_PCR.J3 Buf_GCR.J7 Buf_PCR.J7
Ports Buf_GCR.J8 Buf_PCR.J8 Buf_GCR.K2 Buf_PCR.K2 Buf_GCR.K3 Buf_PCR.K3 Buf_GCR.K7 Buf_PCR.K7
Ports Buf_GCR.K8 Buf_PCR.K8 Buf_GCR.L1 Buf_PCR.L1 Buf_GCR.L2 Buf_PCR.L2 Buf_GCR.L3 Buf_PCR.L3
Ports Buf_GCR.L7 Buf_PCR.L7 Buf_GCR.L8 Buf_PCR.L8 Buf_PDR.L9 Buf_PUR.L9 Buf_GCR.M2 Buf_PCR.M2
Ports Buf_GCR.M3 Buf_PCR.M3 Buf_GCR.M7 Buf_PCR.M7 Buf_GCR.M8 Buf_PCR.M8 Buf_GCR.N2 Buf_PCR.N2
Ports Buf_GCR.N3 Buf_PCR.N3 Buf_GCR.N8 Buf_PCR.N8
[End Package Model]
| Examples of alternative package models delivered with this IBIS file
| These are added to discuss the "Use Model" of these package models
| These examples exclude any controversial swathing technigues
|One package model per Buffer
[Begin Package Model] IOA3
| This model uses I/O pin A3
Language Touchstone
File Value ioA3.s2p
Ports  Pin.A3  Buf.A3
[End Package Model]
[Begin Package Model] IOA7
| This model uses I/O pin A7
Language Touchstone
File Value ioA7.s2p
Ports  Pin.A7  Buf.A7
[End Package Model]
...
[Begin Package Model] IOB3C3
| This model uses differential I/O pins B3 and C3
Language Touchstone
File Value ioB3C3.s4p
Ports  Pin.B3  Pin.C3 Buf.B3  Buf.C3
[End Package Model]
| One subckt, parameterized by length for each pin
[Begin Package Model] IOA3
| This model uses I/O pin A3
Language IBIS_ISS
File Value io.iss
Subckt io
Parameter Length Value 10.   | 10mm
Ports  Pin.A3  Buf.A3
[End Package Model]
[Begin Package Model] IOA7
| This model uses I/O pin A7
Language IBIS_ISS
File Value io.iss
Subckt io
Parameter Length Value 14.   | 14mm
Ports  Pin.A7  Buf.A7
[End Package Model]
|One package model per Model Name
[Begin Package Model] DQ
| This model uses I/O [Model] DQ
Language Touchstone
File Value ioDQ.s2p
Ports  Pin_Mod.DQ  Buf_Mod.DQ
[End Package Model]
[Begin Package Model] INPUT
| This model uses I/O [Model] INPUT
Language Touchstone
File Value INPUT.s2p
Ports  Pin_Mod.INPUT  Buf_Mod.INPUT
[End Package Model]
...
[Begin Package Model] DQS
| This model uses I/O [Model] DQS
Language Touchstone
File Value DQS.s4p
Ports  Pin_Mod+.DQS  Pin_Mod-.DQS Buf_Mod+.DQS  Buf_Mod-.DQS
[End Package Model]
|One package model per Model Type
[Begin Package Model] I/O
| This model uses Model Type I/O
Language Touchstone
File Value io.s2p
Ports  Pin_Type.IO  Buf_Type.IO
[End Package Model]
| This model uses I/O Model Type INPUT
Language Touchstone
File Value INPUT.s2p
Ports  Pin_Type.I  Buf_Type.I
[End Package Model]
...
[Begin Package Model] Differential_I/O
| This model uses I/O Model Type Differential I/O
Language Touchstone
File Value DQS.s4p
Ports  Pin_Type+.IO  Pin_Type-.IO Pin_Type+.IO  Pin_Type-.IO
[End Package Model]
|One package model per Model Type, with DelayCorner
[Begin Package Model] I/O
| This model uses Model Type I/O
Language Touchstone
File DelayCorner io_typ.s2p io_fast.s2p io_slow.s2p
Ports  Pin_Type.IO  Buf_Type.IO
[End Package Model]
| This model uses I/O Model Type INPUT
Language Touchstone
File DelayCorner INPUT_typ.s2p INPUT_fast.s2p INPUT_slow.s2p
Ports  Pin_Type.I  Buf_Type.I
[End Package Model]
...
[Begin Package Model] Differential_I/O
| This model uses I/O Model Type Differential I/O
Language Touchstone
File DelayCorner DQS_typ.s4p DQS_fast.s4p DQS_slow.s4p
Ports  Pin_Type+.IO  Pin_Type-.IO Pin_Type+.IO  Pin_Type-.IO
[End Package Model]
| Models and submodels in the file (0): 
